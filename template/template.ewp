# IAR project template.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: STM32F407xx
  ICCARM.CCIncludePath2: ..\source\CMSIS\Include; ..\source\CMSIS\Device\ST\STM32F4xx\Include; ..\source\user\inc\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: template.hex
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkIcfFile: ..\source\CMSIS\Device\ST\STM32F4xx\Source\iar\linker\stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STM32F407xx
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: New_project.hex
  ILINK.IlinkOutputFile: new_project.out
  group CMSIS/Device/ST/STM32F4xx/Include
    ../source/CMSIS/Device/ST/STM32F4xx/Include/: stm32f407xx.h stm32f4xx.h system_stm32f4xx.h
  group CMSIS/Device/ST/STM32F4xx/Source
    ../source/CMSIS/Device/ST/STM32F4xx/Source/: system_stm32f4xx.c
  group CMSIS/Device/ST/STM32F4xx/Source/iar
    ../source/CMSIS/Device/ST/STM32F4xx/Source/iar/: startup_stm32f407xx.s
  group CMSIS/Device/ST/STM32F4xx/Source/iar/linker
    ../source/CMSIS/Device/ST/STM32F4xx/Source/iar/linker/: stm32f407xx_flash.icf
  group CMSIS/Include
    ../source/CMSIS/Include/: arm_math.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
  group user
    ../source/user/: main.c
